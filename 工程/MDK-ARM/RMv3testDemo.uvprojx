# Keil uVision project RMv3testDemo.uvprojx, settings and files
target RMv3testDemo (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RMv3testDemo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Test\Inc;..\bottom\Inc;..\middle\Inc;..\top\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Test
    ../Test/Src/: test_can.c test_uart.c test_app.c test_beep.c test_usb.c
  group top
    ../top/Src/: main.c stm32f4xx_it.c t_protocol.c t_moto.c control.c t_remote.c t_tk1.c egg_task.c mcu_task.c t_cylinder.c
  group middle
    ../middle/Src/: pid.c m_remote.c m_protocol.c m_toggle.c m_imu.c m_moto.c
  group bottom
    ../bottom/Src/: can.c dma.c gpio.c spi.c stm32f4xx_hal_msp.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group read
    ../: read.txt
software components: CMSIS:CORE 4.1.0
